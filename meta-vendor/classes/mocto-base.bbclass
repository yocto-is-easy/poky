inherit core-image

IMAGE_FSTYPES = "rpi-sdimg"

IMAGE_INSTALL += " openssh python3 supervisor"
